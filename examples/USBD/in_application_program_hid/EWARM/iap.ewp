# IAR project iap.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xC GD GD32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\Utilities; ..\..\..\..\Firmware\GD32F10x_usbd_library\class\device\iap\Include; ..\..\..\..\Firmware\GD32F10x_usbd_library\device\Include; ..\..\..\..\Firmware\GD32F10x_usbd_library\usbd\Include; ..\..\..\..\Firmware\GD32F10x_usbd_library\class\device\hid\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_IAP.srec
  ILINK.IlinkOutputFile: iap.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: flash_operation.c gd32f10x_it.c gd32f10x_usbd_hw.c main.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f10x_eval.c
  group GD32F10x_Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_hd.s
  group USBD_Class
    ../../../../Firmware/GD32F10x_usbd_library/class/device/iap/Source/: usb_iap_core.c
  group USBD_Device
    ../../../../Firmware/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Driver
    ../../../../Firmware/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
