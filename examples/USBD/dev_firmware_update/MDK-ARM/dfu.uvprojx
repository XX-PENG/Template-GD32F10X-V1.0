# Keil uVision project dfu.uvprojx, settings and files
target dfu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dfu +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\usbd\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\device\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\class\device\dfu\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../src/: main.c systick.c gd32f10x_it.c gd32f10x_usbd_hw.c exmc_nandflash.c gd25qxx.c inter_flash_if.c nand_flash_if.c nor_flash_if.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_spi.c
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f10x_eval.c
  group USBD_Drivers
    ../../../../Firmware/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../Firmware/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../Firmware/GD32F10x_usbd_library/class/device/dfu/Source/: dfu_core.c dfu_mem.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
